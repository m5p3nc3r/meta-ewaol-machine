EXTRA_OECONF += "--enable-static"
DISABLE_STATIC = ""
